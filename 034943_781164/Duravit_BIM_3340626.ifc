Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Wash-basins_DURAVIT-AG_DuraStyle-Washbowl-430-mm-034943.ifc
Time: 2023-02-03T15:18:18
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: DuraStyle Washbowl 430 mm - 034943
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DuraStyle Washbowl 430 mm - 034943; SKU (BO_prodsku): DuraStyle-Washbowl-430-mm-034943; ManufacturName (BO_Manufac): DURAVIT AG; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): DuraStyle; ProductGroup (BO_prodgroup): Washbowl; DesignCountry (BO_designcont): Germany; EditionNumber (BO_edinum): 1; Width (BO_width): 430; Height (BO_height): 120; Depth (BO_depth): 380; Weight (BO_weight): 10.3; QR (BO_boqrurl): http://bimobject.com/duravit/product/DuraStyle-Washbowl-430-mm-034943; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/DuraStyle-Washbowl-430-mm-034943; ProductUrl (BO_producturl): http://pro.duravit.com/p/034943; InstallationInstructions (BO_montins): https://pro.duravit.com/p/034943; ProductCertification (BO_prodcert): http://pro.duravit.com/p/034943; TechnicalDescription (BO_techcert): http://pro.duravit.com/p/034943; InstructionVideo (BO_youtube): http://pro.duravit.com/p/034943; MaterialMain (BO_mainmat): Ceramics; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Wash basins; BimObjectCategoryCode (BO_bocat_code): wash-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 30181504; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96; Uniclass2015Description (BO_uniclass2015_desc): Wash basins, sinks and troughs; OmniClassCode (BO_omniclass_code): 23-31 13 00; OmniClassDescription (BO_omniclass_name): Sinks; MasterFormat2014Code (BO_masterformat2014_code): 22 41 16.13; MasterFormat2014Description (BO_masterformat2014_name): Residential Lavatories; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
